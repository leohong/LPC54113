# Keil uVision project appcode.uvprojx, settings and files
target docking_board (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: docking_board +hex
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A008200)
  AfterMake: ..\total\AfxToBin.bat @L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4,NO_BOARD_LIB
  c include: ..\..\src\drv\board\chip\CMSIS\Include;..\..\src\drv\board\chip\chip_common;..\..\src\drv\board\chip\chip_18xx_43xx;..\..\src\drv\board\chip\chip_18xx_43xx\config_43xx;..\..\src\drv\board\chip\usbd_rom;..\..\src\drv\board\chip\usb_api\usb_cdc\include;..\..\src\Configuration_Files;..\..\src\thirdparty\freertos\freertos\Source\include;..\..\src\thirdparty\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\src\thirdparty\freertos\freertoslpc;..\..\src\app\include;..\..\src\hal\include;..\..\src\drv\include;..\..\src\drv\board\include;..\..\src\util\include;..\..\src\thirdparty\Optoma_CLI\include;..\..\src\thirdparty\Calibre_CLI\include;..\..\src\thirdparty\ITE66341\IT6634_Customer;..\..\src\thirdparty\ITE66341\IT6634_Source;..\..\src\thirdparty\ITE66341
  asm define: NO_CRP
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT6: RAM 0x10080000 size 0xa000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\src\Configuration_Files\appcode_m4.sct
  link misc: --keep bootcode.o
  group Configuration_Files
    ../../src/Configuration_Files/: CommonDef.h FreeRTOSConfig.h sysinit.c bootcode.s keil_startup_lpc18xx43xx.s Release.h TaskConfig.h appcode_m4.sct
  group app
    ../../src/app/: main.c appSysmon.c appInputProc.c appIapProc.c appHdmiSwitcher.c
  group hal
    ../../src/hal/: halInputCtrl.c halBoard.c halHdmiSwitcher.c halCard.c
  group drv
    ../../src/drv/: dvCard.c
  group board
    ../../src/drv/board/: Board.c Board_Gpio.c Board_Clock.c Board_Uart.c Board_I2C.c Board_Sw_I2C.c Board_Spi.c Board_Timer.c Board_GPDMA.c
  group util
    ../../src/util/: utilLog.c utilCounter.c utilTask.c utilEventHandler.c utilFuncTester.c utilHost.c utilCLICmd.c
  group freertos
    ../../src/thirdparty/freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group lib
    ../../src/thirdparty/freertos/: lib_freertos.lib
    ../../src/drv/board/chip/: lib_lpc_chip_43xx_m4.lib
  group usb_cdc
    ../../src/drv/board/chip/usb_api/usb_cdc/: cdc_desc.c cdc_uart.c cdc_vcom.c cdc_main.c
