# Keil uVision project lib_lpc_chip_43xx.uvprojx, settings and files
target lib_chip_43xx_m4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: lib_lpc_chip_43xx_m4 (library)
  AfterMake: Copy_lib_lpc_chip_43xx.bat m4
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\src\drv\board\chip\CMSIS\Include;..\..\src\drv\board\chip\chip_18xx_43xx;..\..\src\drv\board\chip\chip_18xx_43xx\config_43xx;..\..\src\drv\board\chip\chip_common
  asm define: CORE_M4
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../src/drv/board/chip/chip_18xx_43xx/: adc_18xx_43xx.c aes_18xx_43xx.c atimer_18xx_43xx.c ccan_18xx_43xx.c chip_18xx_43xx.c clock_18xx_43xx.c dac_18xx_43xx.c eeprom_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c hsadc_18xx_43xx.c i2c_18xx_43xx.c i2cm_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c otp_18xx_43xx.c pmc_18xx_43xx.c rgu_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c sct_18xx_43xx.c sct_pwm_18xx_43xx.c scu_18xx_43xx.c sdif_18xx_43xx.c sdmmc_18xx_43xx.c spi_18xx_43xx.c ssp_18xx_43xx.c timer_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c sysinit_18xx_43xx.c gpiogroup_18xx_43xx.c pinint_18xx_43xx.c iap_18xx_43xx.c stopwatch_18xx_43xx.c mcpwm_18xx_43xx.c
  group common
    ../../src/drv/board/chip/chip_common/: fpu_init.c ring_buffer.c spifilib_dev_common.c spifilib_fam_standard_cmd.c
target lib_chip_43xx_m0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lib_lpc_chip_43xx_m0 (library)
  AfterMake: Copy_lib_lpc_chip_43xx.bat m0
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\src\drv\board\chip\CMSIS\CMSIS\Include;..\..\src\drv\board\chip\chip_18xx_43xx;..\..\src\drv\board\chip\chip_18xx_43xx\config_43xx_m0app;..\..\src\drv\board\chip\chip_common
  asm define: CORE_M0
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
