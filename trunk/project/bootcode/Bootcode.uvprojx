# Keil uVision project Bootcode.uvprojx, settings and files
target bootcode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootcode +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  AfterMake: AfxToBin.bat M4 @L
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4,NO_BOARD_LIB
  c misc: --c99
  c include: ..\..\src\bootcode\drv\board\chip\CMSIS\Include;..\..\src\bootcode\Configuration_Files;..\..\src\bootcode\drv\Board\chip\chip_common;..\..\src\bootcode\drv\board\chip\chip_18xx_43xx;..\..\src\bootcode\drv\Board\chip\chip_18xx_43xx\config_43xx;..\..\src\thirdparty\freertos\freertos\Source\include;..\..\src\thirdparty\freertos\freertoslpc;..\..\src\thirdparty\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\src\bootcode\drv\Board\include;..\..\src\bootcode\drv\Component\Include;..\..\src\bootcode\Common\include;..\..\src\bootcode\app\include;..\..\src\bootcode\hal\Include;..\..\src\bootcode\util\include;..\..\src\bootcode\drv\include
  asm define: CORE_M4
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Configuration_Files
    ../../src/bootcode/Configuration_Files/: CommonDef.h FreeRTOSConfig.h sysinit.c TaskConfig.h Release.h keil_startup_lpc18xx43xx.s
  group app
    ../../src/bootcode/app/: appIapProc.c appInputProc.c main.c
  group board
    ../../src/bootcode/drv/board/: Board.c Board_Clock.c Board_Gpio.c Board_IAP.c Board_Spi.c Board_Uart.c
  group uril
    ../../src/bootcode/util/: utilCLICmd.c utilCounter.c utilHost.c utilLog.c utilTask.c
  group freertos
    ../../src/bootcode/thirdparty/freertos/freertoslpc/: FreeRTOSCommonHooks.c
  group lib
    ../../src/bootcode/thirdparty/freertos/: lib_freertos.lib
    ../../src/bootcode/drv/board/chip/: lib_lpc_chip_43xx_m4.lib
