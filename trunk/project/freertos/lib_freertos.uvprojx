# Keil uVision project lib_freertos.uvprojx, settings and files
target lib_freertos (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.9.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lib_freertos +hex (library)
  AfterMake: Copy_lib_Freertos.bat
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\src\Configuration_Files;..\..\src\thirdparty\freertos\freertos\Source\include;..\..\src\thirdparty\freertos\freertos\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Configuration Files
    ../../src/Configuration_Files/: FreeRTOSConfig.h
  group freertos
    ../../src/thirdparty/freertos/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../src/thirdparty/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../src/thirdparty/freertos/freertos/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
